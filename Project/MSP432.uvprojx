# Keil uVision project MSP432.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4
  c include: ..\Driver\DSP;..\Include;..\My_Driver\Inc;..\Sys\Inc;..\Driver\CMSIS;..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../Sys/Src/: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Sys
    ../Sys/Src/: baudrate_calculate.c delay.c sysinit.c usart.c BSP_GPIO.c timA.c tim32.c adc.c
  group My_Driver
    ../My_Driver/Src/: BSP_LED.c spi_fpga.c usart_hmi.c bsp_ads1256.c FFT.c Power.c ADS8691.c ADS8691_1.c
  group Lib
    ../Lib/: arm_cortexM4lf_math.lib msp432p4xx_driverlib.lib
